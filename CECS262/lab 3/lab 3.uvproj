# Keil uVision project lab 3.uvproj, settings and files
target Target 1 (MCS-51)
  device: EFM8BB10F8G-QSOP24 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(25000000)
  output: lab 3 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: C:\Keil_v5\C51\INC\SiLABS\shared\si8051Base
  group Source Group 1
    ./: SILABS_STARTUP.A51 main.c
